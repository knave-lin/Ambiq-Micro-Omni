# Keil uVision project pdm_fft.uvprojx, settings and files
target pdm_fft (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: AMA3B1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.1.0
  cpu: IRAM(0x10000000,0x00060000) IROM(0x0000C000,0x000F4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: pdm_fft
  AfterMake: fromelf --bin --output bin\pdm_fft.bin bin\pdm_fft.axf
  AfterMake: fromelf -cedrst --output bin\pdm_fft.txt bin\pdm_fft.axf
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PACKAGE_BGA UNITY_INCLUDE_CONFIG_H __FPU_PRESENT AM_UTIL_FAULTISR_PRINT AM_PART_APOLLO3 AM_FREERTOS keil ENABLE_BURST_MODE=0
  c include: ..\src;..\..\..\..\..\mcu\apollo3;..\..\..\..\..\CMSIS\ARM\Include;..\..\..\..\..\CMSIS\AmbiqMicro\Include;..\..\..\..\..\devices;..\..\..\..\..\utils;..\..\..\..\..\boards\apollo3_evb\bsp;..\..\..\..\..\third_party\FreeRTOSv10.1.1\Source\include;..\..\..\..\..\third_party\FreeRTOSv10.1.1\Source\portable\MemMang;..\..\..\..\..\third_party\FreeRTOSv10.1.1\Source\portable\Keil\AMapollo2
  memory RVCT4: ROM 0xc000 size 0xf4000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\pdm_fft.sct
  link misc: ../../../../../mcu/apollo3/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group Source
    ../../../../../third_party/FreeRTOSv10.1.1/Source/: queue.c tasks.c list.c timers.c
  group MemMang
    ../../../../../third_party/FreeRTOSv10.1.1/Source/portable/MemMang/: heap_2.c
  group AMapollo2
    ../../../../../third_party/FreeRTOSv10.1.1/Source/portable/Keil/AMapollo2/: port.c
  group utils
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group src
    ../src/: pdm_fft.c rtos.c CommandData_Keil.s LicenseData_Keil.s
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../../mcu/apollo3/hal/keil/bin/: libam_hal.lib
    ../../../../../boards/apollo3_evb/bsp/keil/bin/: libam_bsp.lib
    ../lib/: libDSpotter.lib
  group devices
    ../../../../../devices/: am_devices_led.c
